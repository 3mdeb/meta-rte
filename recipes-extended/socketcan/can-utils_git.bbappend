BRANCH = "fix_read_cr_after_command"

SRC_URI = "git://github.com/vitrotv/${BPN}.git;protocol=git;branch=${BRANCH}"
SRCREV = "${AUTOREV}"
