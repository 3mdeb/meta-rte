RDEPENDS:${PN} += " \
    python3-markdown-it-py \
"
