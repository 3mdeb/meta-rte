FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# nooelint: oelint.vars.mispell.unknown
hostname = "rte"
