inherit setuptools3
RDEPENDS_${PN} = " python3-setuptools "
require python-wakeonlan.inc
