# nooelint: oelint.vars.mispell.unknown
TOOLS = "fastboot"
